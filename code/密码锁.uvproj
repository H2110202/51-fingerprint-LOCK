# Keil uVision project 密码锁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 密码锁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h Buzzer.c Buzzer.h MatrixKey.c MatrixKey.h Delay.c Delay.h Key.c Key.h Uart.c UART.h AS608.c AS608.h duoji.c duoji.h Timer0.c Timer0.h
